# Keil uVision project exm.uvprojx, settings and files
target exm (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gpio +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\wenchao_lib\inc;..\..\core;..\..\wenchao_lib\inc_user;..\..\wenchao_lib\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c
  group stm32_guan_lib
    ../../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group stm32_wenchao_lib
    ../../wenchao_lib/drive/: gpio.c systick.c uart.c nvic.c exti.c iwdg.c spi.c nrf2401.c timer.c adc.c i2c.c mpu6050_basic.c complement_filter.c hmc5883.c hmc5883+mpu6050+kalman.c kalman.c my_math.c quaternion_fix.c common_filter.c dac_0832_chip.c iic_ssd1306.c pid.c
    ../../wenchao_lib/user/: balance_car.c
  group ::Device
    RTE/Device/STM32F103C8/: RTE_Device.h startup_stm32f10x_md.s system_stm32f10x.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
